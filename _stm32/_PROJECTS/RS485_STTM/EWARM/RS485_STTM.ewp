# IAR project RS485_STTM.ewp, settings and files
configuration RS485_STTM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x6
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ..\..\..\..\_modules; ..\..\..\..\_modules\drivers; ..\..\..\..\_modules\Lib; ..\..\..\..\_modules\mod1Wire; ..\..\..\..\_modules\modSysClock; ..\..\..\..\freemodbus-v1.5.0\modbus; ..\..\..\..\freemodbus-v1.5.0\modbus\functions; ..\..\..\..\freemodbus-v1.5.0\modbus\include; ..\..\..\..\freemodbus-v1.5.0\modbus\rtu; ..\..\..\..\freemodbus-v1.5.0\port\STM32F030
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: RS485_STTM.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x6.s
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Application/User/LIB
    ../Inc/: board.h
    ../../../../_modules/: debug.c debug.h sysReport.c sysReport.h
    ../../../../_modules/drivers/: drvStorage.h drvStorage_STM32F030xx.c
    ../../../../_modules/mod1Wire/: mod1Wire.c mod1Wire.h
    ../../../../_modules/modSysClock/: modSysClock.c modSysClock.h
    ../../../../_modules/pt-1.4/: pt.h
  group Application/User/MODBUS
    ../../../../freemodbus-v1.5.0/modbus/: mb.c
    ../../../../freemodbus-v1.5.0/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../../../../freemodbus-v1.5.0/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../../../../freemodbus-v1.5.0/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../../freemodbus-v1.5.0/port/STM32F030/: port.h portevent.c portserial.c porttimer.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
