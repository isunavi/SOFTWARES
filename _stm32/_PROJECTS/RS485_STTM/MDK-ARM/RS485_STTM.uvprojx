# Keil uVision project RS485_STTM.uvprojx, settings and files
target RS485_STTM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: RS485_STTM +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\..\..\..\freemodbus-v1.5.0\modbus;..\..\..\..\freemodbus-v1.5.0\modbus\functions;..\..\..\..\freemodbus-v1.5.0\modbus\include;..\..\..\..\freemodbus-v1.5.0\modbus\rtu;..\..\..\..\freemodbus-v1.5.0\port\STM32F030;..\..\..\..\_modules;..\..\..\..\_modules\Lib;..\..\..\..\_modules\mod1Wire;..\..\..\..\_modules\modSysClock;..\..\..\..\_modules\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c
    ../Inc/: board.h
    ../../../../freemodbus-v1.5.0/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../../freemodbus-v1.5.0/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../../../../freemodbus-v1.5.0/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../../../../freemodbus-v1.5.0/modbus/: mb.c
    ../../../../freemodbus-v1.5.0/port/STM32F030/: port.h portevent.c portserial.c porttimer.c
    ../../../../_modules/: debug.c debug.h sysReport.c sysReport.h
    ../../../../_modules/mod1Wire/: mod1Wire.c mod1Wire.h
    ../../../../_modules/modSysClock/: modSysClock.c modSysClock.h
    ../../../../_modules/drivers/: drvStorage.h drvStorage_STM32F030xx.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash.c
software components: CMSIS:CORE 4.1.0
