# IAR project VTRM.ewp, settings and files
configuration VTRM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x6
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: VTRM.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x6.s
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Application/User/vga
    ../Src/: ansi.c fifo.c ps2 table.c ps2.c rcc.c serial.c term.c vga font12.c vga-min.c
    ../Inc/: ansi.h fifo.h font.h gpio.h hardware.h mxconstants.h ps2 table.h ps2.h serial.h stm32f030.h stm32f0xx_hal_conf.h stm32f0xx_it.h vga font12.h vga-min.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
