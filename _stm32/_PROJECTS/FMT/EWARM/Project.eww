<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\BIMBA\EWARM\BIMBA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\FMT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


